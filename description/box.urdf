Commit message: snake built

File: description/box.urdf (robot description, URDF)
Before this commit: robot box, 1 links, 0 joints
Links:
- link base_link: geometry collision box size=1 1 1; visual box size=1 1 1
